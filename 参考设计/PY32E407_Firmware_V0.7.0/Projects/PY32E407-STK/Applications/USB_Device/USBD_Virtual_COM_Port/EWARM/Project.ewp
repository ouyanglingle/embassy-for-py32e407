# IAR project Project.ewp, settings and files
configuration Project (ARM, debug)
  General.OGChipSelectEditMenu: PY32E407xE Puya PY32E407xE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; PY32E407xE
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\Drivers\BSP\PY32E407xx_Start_Kit; ..\..\..\..\..\..\Drivers\CMSIS\Device\PUYA\PY32E407\Include; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\PY32E407_HAL_Driver\Inc; ..\Inc; ..\..\..\..\..\..\Middlewares\PUYA\PY32_USB_Device_Library\Core\Inc; ..\..\..\..\..\..\Middlewares\PUYA\PY32_USB_Device_Library\Class\CDC\Inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: py32e407xE_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Drivers/BSP/PY32E407xx_Start_Kit
    ../../../../../../Drivers/BSP/PY32E407xx_Start_Kit/: py32e407xx_Start_Kit.c
  group Drivers/CMSIS
    ../Src/: system_py32e407.c
  group Drivers/PY32E407_HAL_Driver
    ../../../../../../Drivers/PY32E407_HAL_Driver/Src/: py32e407_hal.c py32e407_hal_cortex.c py32e407_hal_dma.c py32e407_hal_gpio.c py32e407_hal_pwr.c py32e407_hal_pwr_ex.c py32e407_hal_rcc.c py32e407_hal_rcc_ex.c py32e407_hal_uart.c py32e407_hal_usbd.c py32e407_hal_usbd_ex.c py32e407_hal_usbh.c py32e407_ll_usb.c
  group Example/EWARM
    ./: startup_py32e407xx.s
  group Example/User
    ../Src/: main.c py32e407_hal_msp.c py32e407_it.c usbd_cdc_if.c usbd_conf.c usbd_desc.c
  group Middlewares/PY32_USBD_Library/Class
    ../../../../../../Middlewares/PUYA/PY32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Middlewares/PY32_USBD_Library/Core
    ../../../../../../Middlewares/PUYA/PY32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
