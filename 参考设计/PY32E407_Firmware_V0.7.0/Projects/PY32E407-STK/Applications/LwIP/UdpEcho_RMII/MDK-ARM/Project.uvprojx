# Keil uVision project Project.uvprojx, settings and files
target Project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: PY32E407xE Puya
  pack: Puya.PY32E4xx_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x20018000,0x00004000) IROM(0x08000000,0x00080000) XRAM(0x2001C000,0x00008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,PY32E407xE
  c include: ..\Inc;..\..\..\..\..\..\Drivers\BSP\PY32E407xx_Start_Kit;..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Drivers\CMSIS\Device\PUYA\PY32E407\Include;..\..\..\..\..\..\Drivers\PY32E407_HAL_Driver\Inc;..\User;..\User\arch;..\..\..\..\..\..\Middlewares\PUYA\Third_Party\LwIP\include;..\..\..\..\..\..\Middlewares\PUYA\Third_Party\LwIP\include\compat;..\..\..\..\..\..\Middlewares\PUYA\Third_Party\LwIP\include\lwip;..\..\..\..\..\..\Middlewares\PUYA\Third_Party\LwIP\include\lwip\apps;..\..\..\..\..\..\Middlewares\PUYA\Third_Party\LwIP\include\lwip\priv;..\..\..\..\..\..\Middlewares\PUYA\Third_Party\LwIP\include\lwip\prot;..\..\..\..\..\..\Middlewares\PUYA\Third_Party\LwIP\netif
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT6: RAM 0x2001c000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x20018000 size 0x4000
  group Common
    ./: startup_py32e407xx.s
    ../Src/: system_py32e407.c
  group Application/User
    ../Src/: main.c py32e407_hal_msp.c py32e407_it.c
  group BSP/py32e407xx_Start_Kit
    ../../../../../../Drivers/BSP/PY32E407xx_Start_Kit/: py32e407xx_Start_Kit.c
  group Drivers/PY32E407_HAL_Driver
    ../../../../../../Drivers/PY32E407_HAL_Driver/Src/: py32e407_hal.c py32e407_hal_rcc.c py32e407_hal_rcc_ex.c py32e407_hal_gpio.c py32e407_hal_dma.c py32e407_hal_pwr.c py32e407_hal_pwr_ex.c py32e407_hal_uart.c py32e407_hal_cortex.c py32e407_hal_eth.c
  group Lwip/api
    ../../../../../../Middlewares/PUYA/Third_Party/LwIP/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../../../Middlewares/PUYA/Third_Party/LwIP/apps/lwiperf/: lwiperf.c
  group Lwip/core
    ../../../../../../Middlewares/PUYA/Third_Party/LwIP/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../../../../Middlewares/PUYA/Third_Party/LwIP/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group Lwip/netif
    ../../../../../../Middlewares/PUYA/Third_Party/LwIP/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c zepif.c
  group Lwip/arch
    ../User/arch/: ethernetif.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.6.0
