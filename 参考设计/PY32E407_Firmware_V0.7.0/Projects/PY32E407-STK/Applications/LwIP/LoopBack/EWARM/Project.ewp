# IAR project Project.ewp, settings and files
configuration Project (ARM, debug)
  General.OGChipSelectEditMenu: PY32E407xE Puya PY32E407xE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; PY32E407xE
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\Drivers\BSP\PY32E407xx_Start_Kit; ..\..\..\..\..\..\Drivers\CMSIS\Device\PUYA\PY32E407\Include; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\PY32E407_HAL_Driver\Inc; ..\Inc; ..\User; ..\..\..\..\..\..\Middlewares\PUYA\Third_Party\LwIP\include; ..\..\..\..\..\..\Middlewares\PUYA\Third_Party\LwIP\include\compat; ..\..\..\..\..\..\Middlewares\PUYA\Third_Party\LwIP\include\lwip; ..\..\..\..\..\..\Middlewares\PUYA\Third_Party\LwIP\include\lwip\apps; ..\..\..\..\..\..\Middlewares\PUYA\Third_Party\LwIP\include\lwip\priv; ..\..\..\..\..\..\Middlewares\PUYA\Third_Party\LwIP\include\lwip\prot; ..\..\..\..\..\..\Middlewares\PUYA\Third_Party\LwIP\include\netif; ..\User\arch
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: py32e407xE_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_py32e407xx.s
  group Application/User
    ../Src/: main.c py32e407_hal_msp.c py32e407_it.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/PY32E407xx_Start_Kit
    ../../../../../../Drivers/BSP/PY32E407xx_Start_Kit/: py32e407xx_Start_Kit.c
  group Drivers/CMSIS
    ../Src/: system_py32e407.c
  group Drivers/PY32E407_HAL_Driver
    ../../../../../../Drivers/PY32E407_HAL_Driver/Src/: py32e407_hal.c py32e407_hal_cortex.c py32e407_hal_dma.c py32e407_hal_eth.c py32e407_hal_gpio.c py32e407_hal_pwr.c py32e407_hal_pwr_ex.c py32e407_hal_rcc.c py32e407_hal_rcc_ex.c py32e407_hal_uart.c
  group Middlewares/LwIP/Api
    ../../../../../../Middlewares/PUYA/Third_Party/LwIP/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Middlewares/LwIP/Arch
    ../User/arch/: ethernetif.c
  group Middlewares/LwIP/Core
    ../../../../../../Middlewares/PUYA/Third_Party/LwIP/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group Middlewares/LwIP/Core/IPv4
    ../../../../../../Middlewares/PUYA/Third_Party/LwIP/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group Middlewares/LwIP/Netif
    ../../../../../../Middlewares/PUYA/Third_Party/LwIP/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
