# Keil uVision project Project.uvprojx, settings and files
target Project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: PY32E407xE Puya
  pack: Puya.PY32E4xx_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x20018000,0x00004000) IROM(0x08000000,0x00080000) XRAM(0x2001C000,0x00008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,PY32E407xE
  c include: ..\Inc;..\..\..\..\..\..\Drivers\BSP\PY32E407xx_Start_Kit;..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Drivers\CMSIS\Device\PUYA\PY32E407\Include;..\..\..\..\..\..\Drivers\PY32E407_HAL_Driver\Inc;..\..\..\..\..\..\Middlewares\PUYA\PY32_USB_Host_Library\Core\Inc;..\..\..\..\..\..\Middlewares\PUYA\PY32_USB_Host_Library\Class\MSC\Inc;..\..\..\..\..\..\Middlewares\PUYA\Third_Party\FatFs\source;..\App
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT6: RAM 0x2001c000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x20018000 size 0x4000
  group Common
    ./: startup_py32e407xx.s
    ../Src/: system_py32e407.c
  group Application/User
    ../Src/: main.c py32e407_hal_msp.c py32e407_it.c usbh_conf.c
  group Application/USB_Host/App
    ../App/: file_operations.c
  group BSP/py32e407xx_Start_Kit
    ../../../../../../Drivers/BSP/PY32E407xx_Start_Kit/: py32e407xx_Start_Kit.c
  group Drivers/PY32E407_HAL_Driver
    ../../../../../../Drivers/PY32E407_HAL_Driver/Src/: py32e407_hal.c py32e407_hal_rcc.c py32e407_hal_rcc_ex.c py32e407_hal_gpio.c py32e407_hal_dma.c py32e407_hal_pwr.c py32e407_hal_pwr_ex.c py32e407_hal_uart.c py32e407_hal_cortex.c py32e407_ll_usb.c py32e407_hal_usbh.c
  group Middlewares/PY32_USBH_Library/Core
    ../../../../../../Middlewares/PUYA/PY32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
  group Middlewares/PY32_USBH_Library/Class
    ../../../../../../Middlewares/PUYA/PY32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group Middlewares/FatFS/Core
    ../../../../../../Middlewares/PUYA/Third_Party/FatFs/source/: diskio.c ff.c ffsystem.c ffunicode.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.2.0
