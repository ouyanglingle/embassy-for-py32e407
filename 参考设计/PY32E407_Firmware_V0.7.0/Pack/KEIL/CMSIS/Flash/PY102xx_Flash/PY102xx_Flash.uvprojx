# Keil uVision project PY102xx_Flash.uvprojx, settings and files
target PY102xx_128 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: PY32E407xE Puya
  pack: Puya.PY32E4xx_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x20018000,0x00004000) IROM(0x08000000,0x00080000) XRAM(0x2001C000,0x00008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: PY102xx_128
  AfterMake: cmd.exe /C copy "!L" ".\Out\@L.FLM"
  c flags: Optim=2 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: FLASH_MEM PY102xx_128
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT6: RAM 0x2001c000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x20018000 size 0x4000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target PY102xx_256 (6220000::V6.22::ARMCLANG)
  device: PY32E407xE Puya
  pack: Puya.PY32E4xx_DFP.1.0.0
  cpu: as above
  output: PY102xx_256
  AfterMake: cmd.exe /C copy "!L" ".\Out\@L.FLM"
  c flags: Optim=2 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: FLASH_MEM PY102xx_256
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT6: RAM 0x2001c000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x20018000 size 0x4000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target PY102xx_384 (6220000::V6.22::ARMCLANG)
  device: PY32E407xE Puya
  pack: Puya.PY32E4xx_DFP.1.0.0
  cpu: as above
  output: PY102xx_384
  AfterMake: cmd.exe /C copy "!L" ".\Out\@L.FLM"
  c flags: Optim=2 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: FLASH_MEM PY102xx_384
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT6: RAM 0x2001c000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x20018000 size 0x4000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target PY102xx_512 (6220000::V6.22::ARMCLANG)
  device: PY32E407xE Puya
  pack: Puya.PY32E4xx_DFP.1.0.0
  cpu: as above
  output: PY102xx_512
  AfterMake: cmd.exe /C copy "!L" ".\Out\@L.FLM"
  c flags: Optim=2 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: FLASH_MEM PY102xx_512
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT6: RAM 0x2001c000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x20018000 size 0x4000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target FLASH_OB (6220000::V6.22::ARMCLANG)
  device: PY32E407xE Puya
  pack: Puya.PY32E4xx_DFP.1.0.0
  cpu: as above
  output: PY102xx_OB
  AfterMake: cmd.exe /C copy "!L" ".\Out\@L.FLM"
  c flags: Optim=2 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: FLASH_OB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT6: RAM 0x2001c000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x20018000 size 0x4000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target FLASH_OTP (6220000::V6.22::ARMCLANG)
  device: PY32E407xE Puya
  pack: Puya.PY32E4xx_DFP.1.0.0
  cpu: as above
  output: PY102xx_OTP
  AfterMake: cmd.exe /C copy "!L" ".\Out\@L.FLM"
  c flags: Optim=2 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: FLASH_OTP FLASH_MEM
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT6: RAM 0x2001c000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x20018000 size 0x4000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
software components: CMSIS:CORE 5.6.0, CMSIS:CORE 6.1.0
