# Keil uVision project Project.uvprojx, settings and files
target PY32E407xE_Project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: PY32E407xE Puya
  pack: Puya.PY32E4xx_DFP.1.0.2
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: PY32E407xE,USE_FULL_LL_DRIVER
  c include: ..\Inc;..\..\..\Drivers\CMSIS\Include;..\..\..\Drivers\CMSIS\Device\PUYA\PY32E407\Include;..\..\..\Drivers\PY32E407_HAL_Driver\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Common
    ./: startup_py32e407xx.s
    ../Src/: system_py32e407.c
  group Application/User
    ../Src/: main.c py32e407_it.c
  group Drivers/PY32E407_HAL_Driver
    ../../../Drivers/PY32E407_HAL_Driver/Src/: py32e407_ll_utils.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.2.0
