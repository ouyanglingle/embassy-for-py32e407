# Keil uVision project demo.uvprojx, settings and files
target demo (6220000::V6.22::ARMCLANG)
  device: PY32E407xE Puya
  pack: Puya.PY32E4xx_DFP.1.0.2
  cpu: IRAM(0x20000000,0x20024000) IROM(0x08000000,0x08080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: demo +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: PY32E407xE,USE_HAL_DRIVER
  c include: ../Core/INC;../Drivers/CMSIS/Include;../Drivers/PY32E407_HAL_Driver/Inc;../Drivers/CMSIS/Device/PY32E407/Include
  library: MicroLIB
  memory RVCT1: ROM 0 size 0
  memory RVCT2: ROM 0 size 0
  memory RVCT3: ROM 0 size 0
  memory RVCT4: ROM 134217728 size 524288
  memory RVCT5: ROM 0 size 0
  memory RVCT6: RAM 0 size 0
  memory RVCT7: RAM 0 size 0
  memory RVCT8: RAM 0 size 0
  memory RVCT9: RAM 536870912 size 147456
  memory RVCT10: RAM 0 size 0
  group Application/MDK-ARM
    ./: startup_py32e407xx.s
  group Application/User/Core
    ../Core/SRC/: main.c gpio.c rng.c cordic.c crc.c tim.c usb_otg_fs.c esmc.c fdcan.c lpuart.c uart.c usart.c spi.c i2c.c rcc.c py32e407_it.c py32e407_hal_msp.c
  group Drivers/CMSIS
    ../Core/SRC/: system_py32e407.c
  group Drivers/PY32E407_HAL_Driver
    ../Drivers/PY32E407_HAL_Driver/Src/: py32e407_hal.c py32e407_hal_rcc.c py32e407_hal_rcc_ex.c py32e407_hal_pwr.c py32e407_hal_cortex.c py32e407_hal_dma.c py32e407_hal_flash.c py32e407_hal_flash_ex.c py32e407_hal_gpio.c py32e407_hal_pwr_ex.c py32e407_hal_exti.c py32e407_hal_i2c.c py32e407_hal_i2c_ex.c py32e407_hal_spi.c py32e407_hal_usart.c py32e407_hal_usart_ex.c py32e407_hal_sci.c py32e407_hal_sci_ex.c py32e407_hal_irda.c py32e407_hal_smartcard.c py32e407_hal_smartcard_ex.c py32e407_hal_uart.c py32e407_hal_lpuart.c py32e407_hal_lpuart_ex.c py32e407_hal_cordic.c py32e407_hal_tim.c py32e407_hal_tim_ex.c py32e407_hal_crc.c py32e407_hal_crc_ex.c py32e407_hal_rng.c py32e407_hal_fdcan.c py32e407_hal_esmc.c
